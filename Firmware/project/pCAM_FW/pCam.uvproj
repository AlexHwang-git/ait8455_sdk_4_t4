# Keil uVision project pCam.uvproj, settings and files
target pCam_FW (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: IRAM(0x300000-0x313FFF) IROM(0x400000-0x41FFFF) CLOCK(16367660) CPUTYPE(ARM926EJ-S)
  output: pCam
  AfterMake: PostLink_visionv3_flash.bat
  c flags: Optim=3 wLevel=1
  c define: ALL_FW BUILD_CE VIDEO_DECODER=HW_MP4V CHIP=VSN_V3 BUILD_FW
  c include: C:\Keil\ARM\INC;..\..\include\OS;..\..\include;..\..\driver;..\..\driver\sensor;..\..\BSP;..\..\BSP\include;..\..\lib;..\..\..\Common;..\..\swpack;..\..\audio;..\..\customer;..\..\..\Host\src\config;..\..\..\Host\src\mmpd;..\..\..\Host\src\mmph;..\..\..\Host\src\mmps;..\..\..\Host\src\Include;..\..\pCam;..\..\include\FS;..\..\driver\fs;..\..\driver\audio;..\pCAM_FW;..\..\driver\video;..\..\driver\3gp;..\..\driver\usb;..\..\audio\wav_decode;..\..\audio\encode;..\..\customer\isp_dv3;..\..\customer\isp_dv3\sensor;..\..\driver\FDFR\include;..\..\driver\FDFR;..\..\include\video;..\..\..\isp_lib;..\..\driver\sf;..\..\driver\WD
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x1000000 size 0x800000
  memory RVCT9: RAM 0x300000 size 0x14000
  scatter file: .\ldsfile_visionv3_flash.txt
  group pCam
    ../../pCam/: pCam_usb.c pCam_api.c pCam_dfu.c pCam_handler.c pCam_msg.c pCam_task32.c
  group MMPD
    ../../../Host/src/mmpd/: mmpd_sensor.c mmpd_system.c mmpd_mp4venc.c mmpd_rawproc.c
  group MMPH
    ../../../Host/src/mmph/: mmph_hif.c
  group MMPS
    ../../../Host/src/mmps/: mmps_3gprecd.c mmps_sensor.c
  group audio
    ../../audio/: mmpf_i2s_ctl.c mmpf_audio_ctl.c
    ../../driver/audio/: mmpf_i2s_irq.s mmpf_afe_irq.s mmpf_audio.c mmpf_audio_task32.c
    ../../audio/wav_decode/: mmpf_wavdecapi.c
    ../../audio/encode/: mmpf_encapi.c
  group bsp
    ../../BSP/: bsp_a.s bsp.c mmu32.c
  group driver
    ../../driver/: mmpf_vif.c mmpf_display.c mmpf_dma.c mmpf_graphics.c mmpf_hif.c mmpf_i2cm.c mmpf_pll.c mmpf_rawproc.c mmpf_scaler.c mmpf_spi.c mmpf_system.c mmpf_timer.c mmpf_uart.c mmpf_dma_irq.s mmpf_graphics_irq.s mmpf_timer_irq.s mmpf_pio.c mmpf_pwm.c mmpf_dram.c mmpf_ibc.c mmpf_icon.c mmpf_fctl.c
    ../../driver/sf/: mmpf_sf.c
    ../../driver/WD/: mmpf_wd.c mmpf_wd_irq.s
  group dsc
    ../../driver/dsc/: mmpf_jpeg_irq.s
  group OS
    ../../driver/: os_wrap.c
    ../../lib/: ucosii_mdk.lib
  group main
    ../../BSP/: cstartup_ram.s lib_retina.c
    ../../driver/: irq.s sys_task32.c
    ../../swpack/: all_fw32.c
  group sensor
    ../../driver/sensor/: mmpf_sensor.c mmpf_sensor_irq.s mmpf_sensor_task32.c
  group usb
    ../../driver/usb/: mmpf_usb_ctl.c mmpf_usbdescr.c mmpf_usbint.c mmpf_usbpccam.c mmpf_usbpub.c mmpf_usbstd.c mmpf_usbuac.c mmpf_usbuvc.c mmpf_usb_irq.s mmpf_usb_task32.c Suspend_Loop.c mmpf_usbvend.h mmpf_msg.c LogitechDesc.lib mmpf_usbuvch264.c Suspend_Wakeup32.c mmpf_usbuvc15h264.c mmpf_usbuvc_hw.c mmpf_usbuvc_vs.c mmpf_usbuvc_event.c mmpf_usbuvc_fdtc.c
  group video record
    ../../driver/video/: mmpf_video_irq.s mmpf_mp4venc_task32.c mmpf_mp4venc_rc.c mmpf_mp4venc.c mmpf_h264enc.c
    ../../driver/3gp/: mmpf_3gpmgr_task32.c mmpf_3gpmgr.c
  group config
    ../../../Host/src/config/: ait_bsp.c ait_config.c
    ../../BSP/include/: config_fw.c config_fw.h
  group customer
    ../../customer/: sensor_ov2710.c sensor_imx045es.c sensor_mt9t002.c
  group isplib
    ../../customer/isp_dv3/: text_ctl32.c hdm_ctl.c
    ../../../isp_lib/: GraceV1_ISP.lib GraceV1_AE.lib GraceV1_AF.lib GraceV1_AWB.lib
  group FDFR
    ../../driver/FDFR/: faceproc.c mxmem.c isqrt.c nvram.c extra.c
    ../../lib/: eOkaCo48.lib eOkaoDt50_HP45.lib
